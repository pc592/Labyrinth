# Keil uVision project lab6.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MK64FN1M0xxx12 NXP
  pack: Keil.Kinetis_K60_DFP.1.4.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: TFT_test_frdm-k64f
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c misc: -DTARGET_KSDK2_MCUS -DDEVICE_RTC=1 -DDEVICE_SLEEP=1 -DTOOLCHAIN_object -DTOOLCHAIN_ARM_STD -DMBED_BUILD_TIMESTAMP=1494801819.27 -DTARGET_KPSDK_CODE --split_sections -DFEATURE_LWIP=1 -D__ASSERT_MSG -DTARGET_RELEASE -DTARGET_MCU_K64F --no_rtti -DARM_MATH_CM4 -DDEVICE_PORTINOUT=1 -DTARGET_FF_ARDUINO -c -DTARGET_RTOS_M4_M7 -DDEVICE_SPISLAVE=1 -DDEVICE_PORTOUT=1 -DDEVICE_FLASH=1 -DDEVICE_STDIO_MESSAGES=1 -DDEVICE_ANALOGOUT=1 -DTARGET_LIKE_MBED -DDEVICE_SERIAL_FC=1 --cpu=Cortex-M4.fp -DTARGET_FRDM -DFEATURE_STORAGE=1 -DTARGET_LIKE_CORTEX_M4 -D__CORTEX_M4 -DDEVICE_ERROR_RED=1 -DTARGET_CORTEX_M -DDEVICE_SERIAL=1 -DTARGET_KPSDK_MCUS -DTARGET_Freescale -DDEVICE_I2C=1 --preinclude=mbed_config.h -DTARGET_MCUXpresso_MCUS -DDEVICE_LOWPOWERTIMER=1 -DTOOLCHAIN_ARM -DDEVICE_INTERRUPTIN=1 -DDEVICE_ANALOGIN=1 -DTARGET_FLASH_CMSIS_ALGO --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED -D__CMSIS_RTOS --md -DDEVICE_PWMOUT=1 -DDEVICE_SERIAL_ASYNCH=1 --gnu -DDEVICE_TRNG=1 --apcs=interwork -DDEVICE_SPI=1 -D__MBED__=1 -DTARGET_K64F -DCPU_MK64FN1M0VMD12 -DDEVICE_STORAGE=1 -DDEVICE_PORTIN=1 -DTARGET_M4 -D__FPU_PRESENT=1 -DDEVICE_I2CSLAVE=1 -DFSL_RTOS_MBED -DDEVICE_SPI_ASYNCH=1 -D__MBED_CMSIS_RTOS_CM
  c include: .;MMA8451Q;MyTouch;SPI_STMPE610;SPI_TFT_ILI9341;TFT_fonts;TFTLCD;mbed/.;mbed/TARGET_K64F;mbed/TARGET_K64F/TARGET_Freescale;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/common;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/common/phyksz8081;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/drivers;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/drivers/clock;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/drivers/clock/src;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/drivers/enet;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/drivers/interrupt;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/drivers/pit;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/adc;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/can;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/dmamux;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/dspi;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/edma;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/enet;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/flextimer;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/gpio;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/i2c;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/mcg;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/osc;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/pit;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/pmc;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/port;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/rtc;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/sai;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/sdhc;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/sim;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/smc;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/uart;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/wdog;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/utilities;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_MCU_K64F;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_MCU_K64F/TARGET_FRDM;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_MCU_K64F/device;mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_MCU_K64F/device/MK64F12;mbed/TARGET_K64F/TOOLCHAIN_ARM_STD
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CORTEX_M4,-DCPU_MK64FN1M0VMD12,-DARM_MATH_CM4,-D__FPU_PRESENT=1,-D__MBED_CMSIS_RTOS_CM,-D__CMSIS_RTOS,-DFSL_RTOS_MBED
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: mbed/TARGET_K64F/TOOLCHAIN_ARM_STD/MK64F.sct
  group mbed
    mbed/: AnalogIn.h analogin_api.h AnalogOut.h analogout_api.h BusIn.h BusInOut.h BusOut.h CallChain.h CAN.h can_api.h can_helper.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h Ethernet.h ethernet_api.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h FunctionPointer.h gpio_api.h gpio_irq_api.h I2C.h i2c_api.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h mbed.h mbed_assert.h mbed_debug.h mbed_error.h mbed_interface.h pinmap.h platform.h port_api.h PortIn.h PortInOut.h PortOut.h PwmOut.h pwmout_api.h RawSerial.h rtc_api.h rtc_time.h semihost_api.h Serial.h serial_api.h SerialBase.h sleep_api.h SPI.h spi_api.h SPISlave.h Stream.h Ticker.h Timeout.h Timer.h TimerEvent.h toolchain.h us_ticker_api.h wait_api.h
    mbed/TARGET_K64F/TOOLCHAIN_ARM_STD/: board.o cmsis_nvic.o mbed.ar mbed_overrides.o retarget.o startup_MK64F12.o sys.o system_MK64F12.o
    mbed/TARGET_K64F/: cmsis.h cmsis_nvic.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h MK64F12.h system_MK64F12.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_MCU_K64F/TARGET_FRDM/: device.h PeripheralNames.h PinNames.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/adc/: fsl_adc_features.h fsl_adc_hal.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/drivers/clock/: fsl_clock_configs.h fsl_clock_manager.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/drivers/clock/src/: fsl_clock_manager_private.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_MCU_K64F/device/: fsl_device_registers.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/dmamux/: fsl_dmamux_features.h fsl_dmamux_hal.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/dspi/: fsl_dspi_features.h fsl_dspi_hal.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/edma/: fsl_edma_features.h fsl_edma_hal.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/drivers/enet/: fsl_enet_driver.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/enet/: fsl_enet_features.h fsl_enet_hal.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/can/: fsl_flexcan_features.h fsl_flexcan_hal.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/flextimer/: fsl_ftm_features.h fsl_ftm_hal.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/gpio/: fsl_gpio_features.h fsl_gpio_hal.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/i2c/: fsl_i2c_features.h fsl_i2c_hal.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/drivers/interrupt/: fsl_interrupt_features.h fsl_interrupt_manager.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/mcg/: fsl_mcg_features.h fsl_mcg_hal.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/utilities/: fsl_os_abstraction.h fsl_os_abstraction_mbed.h sw_timer.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/osc/: fsl_osc_features.h fsl_osc_hal.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/common/phyksz8081/: fsl_phy_driver.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/drivers/pit/: fsl_pit_driver.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/pit/: fsl_pit_features.h fsl_pit_hal.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/pmc/: fsl_pmc_features.h fsl_pmc_hal.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/port/: fsl_port_features.h fsl_port_hal.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/rtc/: fsl_rtc_features.h fsl_rtc_hal.h fsl_rtc_hal_access_control.h fsl_rtc_hal_monotonic.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/sai/: fsl_sai_features.h fsl_sai_hal.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/sdhc/: fsl_sdhc_features.h fsl_sdhc_hal.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/sim/: fsl_sim_features.h fsl_sim_hal.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/smc/: fsl_smc_features.h fsl_smc_hal.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/uart/: fsl_uart_features.h fsl_uart_hal.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_KPSDK_CODE/hal/wdog/: fsl_wdog_features.h fsl_wdog_hal.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_MCU_K64F/: gpio_object.h objects.h PeripheralPins.h PortNames.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KPSDK_MCUS/TARGET_MCU_K64F/device/MK64F12/: MK64F12.h MK64F12_adc.h MK64F12_aips.h MK64F12_axbs.h MK64F12_can.h MK64F12_cau.h MK64F12_cmp.h MK64F12_cmt.h MK64F12_crc.h MK64F12_dac.h MK64F12_dma.h MK64F12_dmamux.h MK64F12_enet.h MK64F12_ewm.h MK64F12_fb.h MK64F12_fmc.h MK64F12_ftfe.h MK64F12_ftm.h MK64F12_gpio.h MK64F12_i2c.h MK64F12_i2s.h MK64F12_llwu.h MK64F12_lptmr.h MK64F12_mcg.h MK64F12_mcm.h MK64F12_mpu.h MK64F12_nv.h MK64F12_osc.h MK64F12_pdb.h MK64F12_pit.h MK64F12_pmc.h MK64F12_port.h MK64F12_rcm.h MK64F12_rfsys.h MK64F12_rfvbat.h MK64F12_rng.h MK64F12_rtc.h MK64F12_sdhc.h MK64F12_sim.h MK64F12_smc.h MK64F12_spi.h MK64F12_uart.h MK64F12_usb.h MK64F12_usbdcd.h MK64F12_vref.h MK64F12_wdog.h regs.h system_MK64F12.h
  group MMA8451Q
    MMA8451Q/: MMA8451Q.cpp MMA8451Q.h
  group MyTouch
    ./MyTouch/: MyTouch.cpp MyTouch.h
  group SPI_STMPE610
    SPI_STMPE610/: SPI_STMPE610.cpp SPI_STMPE610.h
  group SPI_TFT_ILI9341
    SPI_TFT_ILI9341/: GraphicsDisplay.cpp GraphicsDisplay.h SPI_TFT_ILI9341.cpp SPI_TFT_ILI9341.h TextDisplay.cpp TextDisplay.h
  group TFT_fonts
    TFT_fonts/: Arial12x12.h Arial24x23.h Arial28x28.h font_big.h
  group TFTLCD
    ./TFTLCD/: helpers.h hx8340bs.cpp hx8340bs.h ili9328.cpp ili9328.h lcd_base.cpp lcd_base.h ssd1289.cpp ssd1289.h st7735.cpp st7735.h terminus.cpp terminus.h
  group TFT_test_frdm-k64f
    ./: main.cpp mbed_config.h
    ./: mainMain.cpp mainTouch.cpp touchTest.cpp
